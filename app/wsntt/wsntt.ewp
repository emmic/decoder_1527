# IAR project wsntt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x120
  General.GenHeapSize: 0x120
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ; ..\..\mcu\stm8s\; ..\..\mcu\stm8s\src; ..\..\mcu\stm8s\inc; ..\..\dev\hw3000\; ..\..\dev\ev1527\; ..\..\util\delay\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: wsntt.hex
  ILINK.IlinkOutputFile: wsntt.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app/wsntt
    ./: list.c list.h main.c
  group dev
    ../../dev/hw3000/: delay.c delay.h
    ../../dev/ev1527/: ev1527.c ev1527.h
  group mcu/stm8s
    ../../mcu/stm8s/: stm8s_conf.h
  group mcu/stm8s/inc
    ../../mcu/stm8s/inc/: stm8s.h stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_it.h
  group mcu/stm8s/src
    ../../mcu/stm8s/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_it.c
